options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: fm_receiver
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '87900000'
    step: '100000'
    stop: '108000000'
    value: '91300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: vol
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300E-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: gnu_fm_test.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '480000'
    fc: '0'
    fftsize: '4096'
    norm_window: 'True'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: '200000'
    freq0: freq
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_wavfile_sink_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
