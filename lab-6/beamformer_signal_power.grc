options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    generate_options: qt_gui
    id: tx_rx_usrp
    output_language: python
  states: {}

blocks:
- name: Att_dB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bw
  id: variable
  parameters:
    comment: Bandwidth
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding
      Rate
    value: '2'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Beamformer',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.phase_shift = 0
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
          def handle_msg(self, msg):
              #print("Receive phase adjustment: " + str(pmt.to_long(msg)))
              self.phase_shift = pmt.to_long(msg)

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0][:] + (input_items[1][:] * np.exp(1j * np.deg2rad(self.phase_shift)))
              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Angle messenger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.message_port_register_out(pmt.intern('message_out'))
              self.average_list = []
              self.average_list_size = 25
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
          
          def handle_msg(self, msg):
              #print(self.average_list)
              self.message_port_pub(pmt.intern("message_out"), pmt.from_float(max(self.average_list)))

          def work(self, input_items, output_items):
              if len(self.average_list) >= self.average_list_size:
                  self.average_list.pop(0)
              self.average_list.append(input_items[0][-1])
              return len(input_items[0])
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate_rx
    shift: 'False'
    type: complex
  states: {state: disabled}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bw
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate_rx
    sf: sf
    soft_decoding: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rx
    fc: center_freq
    fftsize: '2048'
    rate: '60'
    type: complex
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: RX2
    bw0: bw
    bw1: bw
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    gain0: '10'
    gain1: '10'
    minoutbuf: 2**sf<<2
    nchan: '2'
    samp_rate: samp_rate_rx
    sync: none
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50122
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50123
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:50124
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_1, '0']
- [blocks_nlog10_ff_0, '0', blocks_moving_average_xx_0, '0']
- [epy_block_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', logpwrfft_x_0, '0']
- [epy_block_0, '0', lora_rx_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0, '0']
- [epy_block_1, message_out, zeromq_push_msg_sink_0, in]
- [uhd_usrp_source_0_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0_0, '1', epy_block_0, '1']
- [zeromq_pull_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_pull_msg_source_0_0, out, epy_block_1, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
